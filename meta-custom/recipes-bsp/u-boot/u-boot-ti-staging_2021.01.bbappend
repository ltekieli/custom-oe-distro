FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-beaglebone-make-emmc-default-boot-medium.patch"

