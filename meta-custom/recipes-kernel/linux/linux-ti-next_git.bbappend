# 6.1 version
SRCREV = "830b3c68c1fb1e9176028d02ef86f3cf76aa2476"
PV = "6.1+git${SRCPV}"
