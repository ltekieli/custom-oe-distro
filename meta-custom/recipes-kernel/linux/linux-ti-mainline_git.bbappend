# 5.10 Mainline version
SRCREV = "2c85ebc57b3e1817b6ce1a6b703928e113a90442"
PV = "5.10+git${SRCPV}"
